# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: \Device;.\Driver;.\Source;.\freertos\Source;.\freertos\Source\include;.\freertos\Source\portable\MemMang;.\freertos\Source\portable\MemMang;.\freertos\Source\portable\RVDS\ARM_CM4F;.\freertos\CMSIS\RTOS2\FreeRTOS\Source;.\freertos\CMSIS\RTOS2\FreeRTOS\Include;.\freertos\CMSIS\RTOS2\FreeRTOS\Include1;.\Source\flash memory;.\Source\modbusRTU
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ./Source/: FreeRTOSConfig.h main.c gd32f30x_it.c gd32f30x_it.h atc_e25.c atc_e25.h systick.c systick.h application_task.h application_task.c header_files.h
  group freertos
    ./freertos/CMSIS/RTOS2/FreeRTOS/Source/: freertos_evr.c
    ./freertos/Source/: event_groups.c list.c tasks.c timers.c queue.c
    ./freertos/Source/portable/MemMang/: heap_4.c
    ./freertos/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.2.0, Device:GD32F30x_StdPeripherals:EXTI 1.0.2, Device:GD32F30x_StdPeripherals:GPIO 1.0.2, Device:GD32F30x_StdPeripherals:MISC 1.0.2, Device:GD32F30x_StdPeripherals:PMU 1.0.2, Device:GD32F30x_StdPeripherals:RCU 1.0.2, Device:GD32F30x_StdPeripherals:TIMER 1.0.2, Device:GD32F30x_StdPeripherals:USART 1.0.2, Device:GD32F30x_libopt 1.0.2, Device:Startup 1.0.2
